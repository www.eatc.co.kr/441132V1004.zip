# Autodesk Inventor part: 5-서브축
## iProperties
Created: 2012-07
Part Number: 5-서브축
Document SubType Name: Modeling
Designer: SeoGD™ [www.esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™ [www.esajin.kr]
