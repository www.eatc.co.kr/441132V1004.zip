# Autodesk Inventor part: 3-뚜껑
## iProperties
Created: 2012-07
Part Number: 3-뚜껑
Document SubType Name: Modeling
Designer: SeoGD™ [www.esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™ [www.esajin.kr]
