# Autodesk Inventor part: 4-구동축
## iProperties
Created: 2012-07
Part Number: 4-구동축
Document SubType Name: Modeling
Designer: SeoGD™ [www.esajin.kr]
Density: 1 g/cm^3
Author: SeoGD™ [www.esajin.kr]
